options:
  parameters:
    author: Wylie Standage-Beier
    generate_options: qt_gui
    id: WritingGNURadioBlocks
    output_language: python
    title: Writing GNURadio Blocks
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: WritingGNURadioBlocks_BitErrorCounter_0
  id: WritingGNURadioBlocks_BitErrorCounter
  parameters: {}
  states: {}
- name: WritingGNURadioBlocks_Demodulator_0
  id: WritingGNURadioBlocks_Demodulator
  parameters: {}
  states: {}
- name: WritingGNURadioBlocks_Modulator_0
  id: WritingGNURadioBlocks_Modulator
  parameters: {}
  states: {}
- name: WritingGNURadioBlocks_bit_source_0
  id: WritingGNURadioBlocks_bit_source
  parameters: {}
  states: {}
- name: WritingGNURadioBlocks_channel_0
  id: WritingGNURadioBlocks_channel
  parameters:
    snr: '1.0'
  states: {}

connections:
- [WritingGNURadioBlocks_Demodulator_0, '0', WritingGNURadioBlocks_BitErrorCounter_0, '0']
- [WritingGNURadioBlocks_Modulator_0, '0', WritingGNURadioBlocks_channel_0, '0']
- [WritingGNURadioBlocks_bit_source_0, '0', WritingGNURadioBlocks_BitErrorCounter_0, '1']
- [WritingGNURadioBlocks_bit_source_0, '0', WritingGNURadioBlocks_Modulator_0, '0']
- [WritingGNURadioBlocks_channel_0, '0', WritingGNURadioBlocks_Demodulator_0, '0']

metadata:
  file_format: 1
